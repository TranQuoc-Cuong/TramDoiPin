# Keil uVision project Testing.uvprojx, settings and files
target Testing (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Testing +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/INA219;../Drivers/BATTERY;../Drivers/SERVO;../Drivers/NTC;../Drivers/RINGBUFFER;../Drivers/UART;../Drivers/CMD;..\Services;..\Drivers\DELAY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group INA219
    ../Drivers/INA219/: ina219_manager.c INA219.c
  group BATTERY
    ../Services/: battery_diagnostics.c
    ../Drivers/BATTERY/: battery_control.c
  group SERVO
    ../Drivers/SERVO/: servo_control.c
  group NTC
    ../Drivers/NTC/: ntc_sensor.c
  group RINGBUFF
    ../Drivers/RINGBUFFER/: ringbuffer.c
  group UART
    ../Drivers/UART/: uart_dn.c
  group HANDLE
    ../Drivers/CMD/: handle_cmd.c
  group DELAY
    ../Drivers/DELAY/: soft_timer.h
software components: CMSIS:CORE 4.3.0
